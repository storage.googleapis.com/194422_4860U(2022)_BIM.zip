Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-26T18:58:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 26 18:58:58 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8a4ff089-cb36-42f2-8fd8-901cdd0d1ac6\2cc1ddd9-7e04-453e-8ea3-a6c80abf2a4c\ifc * Database version: 5507 * Database creation date: Fri Apr 26 18:58:57 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 26 18:58:57 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 26 18:58:57 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 4860U Shower faucet, 4860U(2022):4860U Shower faucet:56761
In: Level 1
Type - PredefinedType: FAUCET; Material: Chrome
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 109.248 mm; NominalHeight: 100.184 mm; NominalWidth: 273.767 mm
Type - General - Author: BIMStone; BIMObjectName: 4860U(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 20/04/2024
Type - Green Building Properties - CO2 Emissions (A1-A3): 12.4; CO2 Emissions (A4): 0.44; CO2 Emissions (B7): 2215.5; CO2 Emissions (C2): 0.02; CO2 Emissions (C3): 0.02; CO2 Emissions (C4): 0.88; CO2 Emissions (D): -7.87; EAN Number: 6414150099373; EN Standard: EN 817; ETIM Class Number: EC011329 Shower mixing tap; Noise Class: I (ISO 3822); Sales Package dimensions (LxWxH): 294 x 164 x 83; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/4860U; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://www.oras.com/fileadmin/resources/189401_Oras_EPD_Shower_faucet_2022_06_29.pdf; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/166573_4860U_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/4860U
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/4860U; 3D View: https://static.oras.com/AR/4860U; Catalog Drawing URL: http://static.oras.com/catdrw/4860U; Dimension Drawing URL: http://static.oras.com/dimdrw/4860U; FDV Document URL: http://www.oras.com/datasheet/4860U/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/4860U; Group: Shower faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/4860U; Interactive AR View URL: https://static.oras.com/AR/4860U; Manufacturer: Oras; Market: International;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/4860U; Model: 4860U Shower faucet; Name_en: 4860U Shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 4860U; Product Family: Oras Stela; Product Image URL: http://static.oras.com/image/4860U; Product URL: http://static.oras.com/4860U; Spare-Part Information URL: http://static.oras.com/sp/4860U; Technical DataSheet URL: http://www.oras.com/datasheet/4860U/en; Type Name: 4860U Shower faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Backflow Prevention EN1717: EB; Connection: Eccentric coupling(s); Connection Size: G1/2; Flow Rate At 300kPa: 0.00741608 m3/s; Installation Type: Wall mounted; Installation Width: cc150± 15 mm; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control;Non-return valve(s); Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 4860U(2022); Features: Single-lever, side operated; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 4860U; Name: 4860U Shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 275x110x100 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0702411 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00300652 m3
Identity Data - Mark: 24
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 4860U(2022): 4860U Shower faucet; Family and Type: 4860U(2022): 4860U Shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 4860U(2022): 4860U Shower faucet; Type Id: 4860U(2022): 4860U Shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
